# IAR project ContikiCC253xProj.ewp, settings and files
configuration ContikiBankedRelease (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2531; VP_CONFIG_H="contiki-conf.h"; VP_NASSERT
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: contiki-2.x\; contiki-2.x\core\; contiki-2.x\core\cfs\; contiki-2.x\core\ctk\; contiki-2.x\core\dev\; contiki-2.x\core\lib\; contiki-2.x\core\loader\; contiki-2.x\core\net\; contiki-2.x\core\net\mac\; contiki-2.x\core\net\rime\; contiki-2.x\core\net\routing\; contiki-2.x\core\sys\; contiki-2.x\cpu\; contiki-2.x\cpu\cc2530\; contiki-2.x\cpu\cc2530\dev\; contiki-2.x\cpu\cc2530\dev\uart\; contiki-2.x\cpu\cc2530\dev\uart2\; contiki-2.x\cpu\cc2530\dev\ti\components\usb\class_cdc; contiki-2.x\cpu\cc2530\dev\ti\components\common; contiki-2.x\cpu\cc2530\dev\ti\components\common\cc8051; contiki-2.x\cpu\cc2530\dev\ti\components\usb\library; contiki-2.x\cpu\cc2530\dev\ti\components\usb\library\cc2531; contiki-2.x\cpu\cc2530\dev\ti\components\targets\cc2531_dongle; contiki-2.x\cpu\cc2530\dev\ti\components\targets\interface; contiki-2.x\cpu\cc2530\dev\ti\components\utils; contiki-2.x\platform\; contiki-2.x\platform\dugs\; contiki-2.x\platform\dugs\dev\; contiki-2.x\platform\dugs\dev\vpi\_norm16\; contiki-2.x\examples\; contiki-2.x\examples\hello-world\; contiki-2.x\apps\servreg-hack\
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  A8051.ADefines: chip=2531
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration ContikiBankedDebug (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: chip=2531; VP_CONFIG_H="contiki-conf.h"; VP_STDINT_H="vpi/stdint_fast.h"; VP_NASSERT
  ICC8051.CCDiagSuppress: pe177,pa050
  ICC8051.PreInclude: 8051def.h
  ICC8051.CCIncludePath2: $TOOLKIT_DIR$\INC\DLIB\; contiki-2.5\; contiki-2.5\core\; contiki-2.5\core\cfs\; contiki-2.5\core\ctk\; contiki-2.5\core\dev\; contiki-2.5\core\lib\; contiki-2.5\core\loader\; contiki-2.5\core\net\; contiki-2.5\core\net\mac\; contiki-2.5\core\net\rime\; contiki-2.5\core\net\routing\; contiki-2.5\core\sys\; contiki-2.5\cpu\; contiki-2.5\cpu\cc253x\; contiki-2.5\cpu\cc253x\dev\; contiki-2.5\platform\; contiki-2.5\platform\cc2530dk\; contiki-2.5\platform\cc2530dk\dev\; contiki-2.5\examples\; contiki-2.5\examples\hello-world\
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2531F256_banked.xcl
  group core/cfs
    contiki-2.5/core/cfs/: cfs-coffee.c cfs-eeprom.c cfs-posix-dir.c cfs-posix.c cfs-ram.c cfs-xmem.c
  group core/ctk
    contiki-2.5/core/ctk/: ctk-conio.c ctk-vncfont.c ctk-vncserver.c ctk.c vnc-out.c vnc-server.c
  group core/dev
    contiki-2.5/core/dev/: cc2420-aes.c cc2420.c ds2411.c leds.c nullradio.c serial-line.c sht11-sensor.c sht11.c slip.c
  group core/lib
    contiki-2.5/core/lib/: assert.c checkpoint.c crc16.c ctk-filedialog.c ctk-textentry-checkbox.c ctk-textentry-cmdline.c ctk-textentry-multiline.c gcr.c ifft.c libconio.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c strncasecmp.c
  group core/loader
    contiki-2.5/core/loader/: cle.c cle_avr.c cle_msp430.c cmod.c dlloader.c elfloader-avr.c elfloader-msp430.c elfloader-stub.c elfloader-x86.c elfloader.c elfloader_compat.c sym.c symtab-avr.c symtab.c
  group core/net
    contiki-2.5/core/net/: dhcpc.c hc.c neighbor-attr.c neighbor-info.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c rawpacket-udp.c resolv.c sicslowpan.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-debug.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    contiki-2.5/core/net/mac/: contikimac.c csma.c ctdma_mac.c cxmac.c frame802154.c framer-802154.c framer-nullmac.c lpp.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c sicslowmac.c tdma_mac.c xmac.c
  group core/net/rime
    contiki-2.5/core/net/rime/: abc.c announcement.c broadcast-announcement.c broadcast.c chameleon-bitopt.c chameleon-raw.c chameleon.c channel.c collect-link-estimate.c collect-neighbor.c collect.c ipolite.c mesh.c multihop.c neighbor-discovery.c netflood.c polite-announcement.c polite.c rime-udp.c rime.c rimeaddr.c rimestats.c rmh.c route-discovery.c route.c rucb.c rudolph0.c rudolph1.c rudolph2.c runicast.c stbroadcast.c stunicast.c timesynch.c trickle.c unicast.c
  group core/net/rpl
    contiki-2.5/core/net/rpl/: rpl-dag.c rpl-icmp6.c rpl-of-etx.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    contiki-2.5/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile-aggregates.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group cpu/cc253x
    contiki-2.5/cpu/cc253x/: rtimer-arch.c soc.c
  group cpu/cc253x/dev
    contiki-2.5/cpu/cc253x/dev/: cc2530-rf.c clock.c dma.c dma_intr.c random.c uart-intr.c uart0.c uart1.c watchdog.c
  group examples/rime
    contiki-2.5/examples/rime/: example-abc.c example-announcement.c example-broadcast.c example-collect.c example-mesh.c example-multihop.c example-neighbors.c example-polite.c example-rucb.c example-rudolph0.c example-rudolph1.c example-rudolph2.c example-runicast.c example-trickle.c example-unicast.c
  group platform/cc2530dk
    contiki-2.5/platform/cc2530dk/: contiki-main.c debug.c putchar.c viztool.c
  group platform/cc2530dk/dev
    contiki-2.5/platform/cc2530dk/dev/: adc-sensor.c button-sensor.c leds-arch.c slip-arch.c smartrf-sensors.c
